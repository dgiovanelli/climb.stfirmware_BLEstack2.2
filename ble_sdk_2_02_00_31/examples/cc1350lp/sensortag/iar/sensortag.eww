<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\util\bim_extflash\cc1350\iar\bim_extflash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\app\cc1350lp_app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\stack\cc1350lp_stack.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>cc1350lp_stack</project>
        <configuration>FlashROM</configuration>
      </member>
      <member>
        <project>cc1350lp_app</project>
        <configuration>FlashOnly_OAD</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


