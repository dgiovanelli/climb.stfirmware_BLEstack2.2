# IAR project bim.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; FEATURE_FIXED_IMAGE; FEATURE_OAD; BOOT_LOADER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/profiles/oad/cc26xx; $SRC_EX$/util/bim/cc2640; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/osal/src/inc; $CC26XXWARE$; $CC26XXWARE$/driverlib; $CC26XXWARE$/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bim.hex
  ILINK.IlinkOutputFile: bim.out
  ILINK.IlinkConfigDefines: RTOS_IN_ROM=1
  ILINK.IlinkIcfFile: bim_cc26xx.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_OADTargetDebug (ARM, debug)
  as the first configuration, except:
configuration FlashOnly_LP (ARM, debug)
  as the first configuration, except:
configuration FlashOnly_OADTargetDebug_LP (ARM, debug)
  as the first configuration, except:
  group Application
    $SRC_EX$/examples/util/bim/cc2640/: bim_main.c ccfg_app_ble.c
    $SRC_EX$/profiles/oad/cc26xx/: oad.h oad_target.h oad_target_external_flash.c oad_target_internal_flash.c
    $CC26XXWARE$/startup_files/: startup_iar.c
  group TOOLS
    ./: bim_cc26xx.icf
