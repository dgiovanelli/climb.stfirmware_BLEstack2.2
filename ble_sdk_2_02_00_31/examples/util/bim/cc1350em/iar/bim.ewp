# IAR project bim.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/inc; $SRC_EX$/util/bim/cc1350; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/nv; $SRC_COMMON$/services/src/nv/cc26xx; $CC13XXWARE$; $CC13XXWARE$/driverlib; $CC13XXWARE$/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bim_cc1350em_bim.hex
  ILINK.IlinkOutputFile: bim_cc1350em_bim.out
  ILINK.IlinkConfigDefines: RTOS_IN_ROM=1
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc13xx_bim_dual_img.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC13XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $SRC_EX$/examples/util/bim/cc1350/: bim_main.c ccfg_app_ble.c
    $CC13XXWARE$/startup_files/: startup_iar.c
  group TOOLS
    $SRC_EX$/common/cc26xx/iar/: cc13xx_bim_dual_img.icf
